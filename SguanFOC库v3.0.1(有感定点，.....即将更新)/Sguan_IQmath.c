/*
 * @Author: 星必尘Sguan
 * @GitHub: https://github.com/Sguan-ZhouQing
 * @Date: 2026-02-26 22:37:35
 * @LastEditors: 星必尘Sguan|3464647102@qq.com
 * @LastEditTime: 2026-03-20 22:54:37
 * @FilePath: \SguanFOC_Debug\SguanFOC\Sguan_IQmath.c
 * @Description: SguanFOC库的“IQmath库”实现
 * 
 * Copyright (c) 2026 by 星必尘Sguan, All Rights Reserved. 
 */
#include "Sguan_IQmath.h" // 里面已经包含"Sguan_IQmath.h"

// ===================== Q17.15 常量定义 =====================
#define Q15_SHIFT        15                    // 小数位占15位
#define Q15_MULTIPLIER   (1 << Q15_SHIFT)      // 32768（2^15）
#define Q15_MAX_FLOAT    (Q15_INT_MAX + (Q15_MULTIPLIER - 1.0f) / Q15_MULTIPLIER)
#define Q15_MIN_FLOAT    (float)Q15_INT_MIN    // -65536.0
#define Q15_MAX          ((int32_t)0x7FFFFFFF) // Q17.15最大值（对应65535.999969）
#define Q15_MIN          ((int32_t)0x80000000) // Q17.15最小值（对应-65536.0浮点数）
#define Q15_SCALE        (1.0f / Q15_MULTIPLIER) // 缩放系数（转浮点数用）

// ===================== Q31 常量定义 =====================
#define Q31_ZERO        0x00000000      // 表示0.0

// 浮点常量
#define Q31_MAX_FLOAT   2147483647.0    // Q31_MAX的双精度表示 (2^31-1)
#define Q31_SCALE       (1.0 / 2147483648.0)  // 2^31的倒数

// 预计算64位常量（使用正确的类型）
static const int64_t Q31_MAX_64 = 2147483647LL;
static const int64_t Q31_MIN_64 = -2147483648LL;


// ============================ float 版本代码 ============================

// 重写fmodf函数
static float Value_fmodf(float x, float y) {
  if (y == 0.0f) return 0.0f;
  int quotient = (int)(x / y); // 1次除法运算
  return x - quotient * y;     // 1次乘1次减
}

// 重写fabsf函数
float Value_fabsf(float x){
  union{
    float f;
    uint32_t i;
  }u;
  u.f = x;
  u.i &= 0x7FFFFFFF; // 1次位与操作
  return u.f;
}

// 重写isinf函数
int Value_isinf(float x){
    union{
        float f;
        uint32_t i;
    } u = {x};
    
    // 单精度浮点数格式：
    // 符号位(1bit) | 指数位(8bits) | 尾数位(23bits)
    // 无穷大：指数位全1，尾数位全0
    // 去除符号位后检查
    uint32_t exp_mask = 0x7F800000;  // 指数位全1的掩码
    uint32_t mant_mask = 0x007FFFFF;  // 尾数位掩码
    
    // 检查指数位是否全1且尾数位全0
    if ((u.i & exp_mask) == exp_mask && (u.i & mant_mask) == 0) {
        return 1;  // 是无穷大
    }
    return 0;  // 不是无穷大
}

// 重写isnan函数
int Value_isnan(float x){
    union{
        float f;
        uint32_t i;
    } u = {x};
    
    uint32_t exp_mask = 0x7F800000;  // 指数位全1的掩码
    uint32_t mant_mask = 0x007FFFFF;  // 尾数位掩码
    if ((u.i & exp_mask) == exp_mask && (u.i & mant_mask) != 0) {
        return 1;  // 是NaN
    }
    return 0;  // 不是NaN
}

// 重写sqrtf函数
float Value_sqrtf(float x){
    if (x < 0){
        return 0.0f;  // 返回NaN（0/0产生NaN）
    }
    if (x == 0 || x == 1){
        return x;
    }
    float guess = x;
    float epsilon = 0.00001f;  // 精度要求
    // 牛顿迭代公式：guess = (guess + x/guess) / 2
    while (1) {
        float new_guess = (guess + x / guess) * 0.5f;
        if (new_guess > guess){
            if (new_guess - guess < epsilon){
                return new_guess;
            }
        } else {
            if (guess - new_guess < epsilon){
                return new_guess;
            }
        }
        guess = new_guess;
    }
}

// 数值限幅float版本
float Value_Limit(float val, float max, float min) {
    if (val > max) return max;
    if (val < min) return min;
    return val;
}

// 参数取模[0, 2π)
float Value_normalize(float angle) {
    // float normalized = Value_fmodf(angle, Value_PI*2);
    // // 如果结果为负，加上2π使其在[0, 2π)范围内
    // if (normalized < 0) {
    //     normalized += Value_PI*2;
    // }
    // return normalized;
    while (1) {
        if (angle > 6.2831854f)
            angle -= 6.2831854f;
        else if (angle < 0)
            angle += 6.2831854f;
        else
            break;
    }
    return angle;
}

// 查表法求得float的角度正余弦值
const float sin_tab[512] = {
    0.0f, 0.012296f, 0.024589f, 0.036879f, 0.049164f, 0.061441f, 0.073708f, 0.085965f, 0.098208f, 0.11044f, 
    0.12265f,0.13484f, 0.14702f, 0.15917f, 0.17129f, 0.18339f, 0.19547f, 0.20751f, 0.21952f, 0.2315f, 
    0.24345f, 0.25535f, 0.26722f, 0.27905f, 0.29084f, 0.30258f, 0.31427f, 0.32592f, 0.33752f, 0.34907f, 
    0.36057f, 0.37201f, 0.38339f, 0.39472f, 0.40599f, 0.41719f, 0.42834f, 0.43941f, 0.45043f, 0.46137f, 
    0.47224f, 0.48305f, 0.49378f, 0.50443f, 0.51501f, 0.52551f, 0.53593f, 0.54627f, 0.55653f, 0.5667f, 
    0.57679f, 0.58679f, 0.5967f, 0.60652f, 0.61625f, 0.62589f, 0.63543f, 0.64488f, 0.65423f, 0.66348f, 
    0.67263f, 0.68167f, 0.69062f, 0.69946f, 0.70819f, 0.71682f, 0.72534f, 0.73375f, 0.74205f, 0.75023f, 
    0.75831f, 0.76626f, 0.77411f, 0.78183f, 0.78944f, 0.79693f, 0.80429f,0.81154f, 0.81866f, 0.82566f, 
    0.83254f, 0.83928f, 0.84591f, 0.8524f, 0.85876f, 0.865f, 0.8711f, 0.87708f, 0.88292f,0.88862f, 
    0.89419f, 0.89963f, 0.90493f, 0.9101f, 0.91512f, 0.92001f, 0.92476f, 0.92937f, 0.93384f, 0.93816f,
    0.94235f, 0.94639f, 0.95029f, 0.95405f, 0.95766f, 0.96113f, 0.96445f, 0.96763f, 0.97066f, 0.97354f, 
    0.97628f, 0.97887f, 0.98131f, 0.9836f, 0.98574f, 0.98774f, 0.98958f, 0.99128f, 0.99282f, 0.99422f, 
    0.99546f, 0.99656f, 0.9975f, 0.99829f, 0.99894f, 0.99943f, 0.99977f, 0.99996f, 1.0f, 0.99988f, 0.99962f, 
    0.9992f, 0.99863f, 0.99792f, 0.99705f, 0.99603f, 0.99486f, 0.99354f, 0.99207f, 0.99045f, 0.98868f, 
    0.98676f, 0.98469f, 0.98247f, 0.9801f, 0.97759f, 0.97493f, 0.97212f, 0.96916f, 0.96606f, 0.96281f, 
    0.95941f, 0.95587f, 0.95219f, 0.94836f, 0.94439f, 0.94028f, 0.93602f, 0.93162f, 0.92708f, 0.9224f, 
    0.91758f, 0.91263f, 0.90753f, 0.9023f, 0.89693f, 0.89142f, 0.88579f, 0.88001f, 0.87411f, 0.86807f, 
    0.8619f, 0.8556f, 0.84917f, 0.84261f, 0.83593f, 0.82911f, 0.82218f, 0.81512f, 0.80793f, 0.80062f, 0.7932f, 0.78565f, 0.77798f, 0.7702f, 0.7623f, 0.75428f, 0.74615f, 0.73791f, 0.72956f, 0.72109f, 0.71252f, 
    0.70384f, 0.69505f, 0.68616f, 0.67716f, 0.66806f, 0.65886f, 0.64956f, 0.64017f, 0.63067f, 0.62108f, 
    0.6114f, 0.60162f, 0.59176f, 0.5818f, 0.57176f, 0.56163f, 0.55141f, 0.54111f, 0.53073f, 0.52027f,
    0.50973f, 0.49911f, 0.48842f, 0.47765f, 0.46682f, 0.45591f, 0.44493f, 0.43388f, 0.42277f, 0.4116f, 
    0.40036f, 0.38906f, 0.37771f, 0.36629f, 0.35483f, 0.3433f, 0.33173f, 0.32011f, 0.30843f, 0.29671f, 
    0.28495f, 0.27314f, 0.26129f, 0.2494f, 0.23748f, 0.22552f, 0.21352f, 0.20149f, 0.18943f, 0.17735f, 
    0.16523f, 0.15309f, 0.14093f, 0.12875f, 0.11655f, 0.10432f, 0.092088f, 0.079838f, 0.067576f, 0.055303f, 
    0.043022f, 0.030735f, 0.018443f, 0.0061479f, -0.0061479f, -0.018443f, -0.030735f, -0.043022f, -0.055303f, -0.067576f, -0.079838f, -0.092088f, -0.10432f, -0.11655f, -0.12875f, -0.14093f, -0.15309f, -0.16523f, 
    -0.17735f, -0.18943f, -0.20149f, -0.21352f, -0.22552f, -0.23748f, -0.2494f, -0.26129f, -0.27314f, 
    -0.28495f, -0.29671f, -0.30843f, -0.32011f, -0.33173f,-0.3433f, -0.35483f, -0.36629f, -0.37771f, 
    -0.38906f, -0.40036f, -0.4116f, -0.42277f, -0.43388f, -0.44493f, -0.45591f, -0.46682f, -0.47765f, 
    -0.48842f, -0.49911f, -0.50973f, -0.52027f, -0.53073f, -0.54111f, -0.55141f, -0.56163f, -0.57176f, 
    -0.5818f, -0.59176f, -0.60162f, -0.6114f, -0.62108f, -0.63067f, -0.64017f, -0.64956f, -0.65886f, 
    -0.66806f, -0.67716f, -0.68616f, -0.69505f, -0.70384f, -0.71252f, -0.72109f, -0.72956f, -0.73791f,
    -0.74615f, -0.75428f, -0.7623f, -0.7702f, -0.77798f, -0.78565f, -0.7932f, -0.80062f, -0.80793f, -0.81512f,
    -0.82218f, -0.82911f, -0.83593f, -0.84261f, -0.84917f, -0.8556f, -0.8619f, -0.86807f, -0.87411f, -0.88001f,
    -0.88579f, -0.89142f, -0.89693f, -0.9023f, -0.90753f, -0.91263f, -0.91758f, -0.9224f, -0.92708f, -0.93162f,
    -0.93602f, -0.94028f, -0.94439f, -0.94836f, -0.95219f, -0.95587f, -0.95941f, -0.96281f, -0.96606f, 
    -0.96916f, -0.97212f, -0.97493f, -0.97759f, -0.9801f, -0.98247f, -0.98469f, -0.98676f, -0.98868f, 
    -0.99045f, -0.99207f, -0.99354f, -0.99486f, -0.99603f, -0.99705f, -0.99792f, -0.99863f, -0.9992f, 
    -0.99962f, -0.99988f, -1.0f, -0.99996f, -0.99977f, -0.99943f, -0.99894f, -0.99829f, -0.9975f, -0.99656f, 
    -0.99546f, -0.99422f, -0.99282f, -0.99128f, -0.98958f, -0.98774f, -0.98574f, -0.9836f, -0.98131f, 
    -0.97887f, -0.97628f, -0.97354f, -0.97066f, -0.96763f, -0.96445f, -0.96113f, -0.95766f, -0.95405f, 
    -0.95029f, -0.94639f, -0.94235f, -0.93816f, -0.93384f, -0.92937f, -0.92476f, -0.92001f, -0.91512f, 
    -0.9101f, -0.90493f, -0.89963f, -0.89419f, -0.88862f, -0.88292f, -0.87708f, -0.8711f, -0.865f, -0.85876f, 
    -0.8524f, -0.84591f, -0.83928f, -0.83254f, -0.82566f, -0.81866f, -0.81154f, -0.80429f, -0.79693f, 
    -0.78944f, -0.78183f, -0.77411f, -0.76626f, -0.75831f, -0.75023f, -0.74205f, -0.73375f, -0.72534f,
    -0.71682f, -0.70819f, -0.69946f, -0.69062f, -0.68167f, -0.67263f, -0.66348f, -0.65423f, -0.64488f, 
    -0.63543f, -0.62589f, -0.61625f, -0.60652f, -0.5967f, -0.58679f, -0.57679f, -0.5667f, -0.55653f, 
    -0.54627f, -0.53593f, -0.52551f, -0.51501f, -0.50443f, -0.49378f, -0.48305f, -0.47224f, -0.46137f, 
    -0.45043f, -0.43941f, -0.42834f, -0.41719f, -0.40599f, -0.39472f, -0.38339f, -0.37201f, -0.36057f, 
    -0.34907f, -0.33752f, -0.32592f, -0.31427f, -0.30258f, -0.29084f, -0.27905f, -0.26722f, -0.25535f, 
    -0.24345f, -0.2315f, -0.21952f, -0.20751f, -0.19547f, -0.18339f, -0.17129f, -0.15917f, -0.14702f, 
    -0.13484f, -0.12265f, -0.11044f, -0.098208f, -0.085965f, -0.073708f, -0.061441f, -0.049164f, -0.036879f, 
    -0.024589f, -0.012296f, 0.0f
};

// 快速正弦算法
float fast_sin(float theta) {
    while (1) {
        if (theta > 6.2831854f)
            theta = theta - 6.2831854f;
        else if (theta < 0)
            theta = theta + 6.2831854f;
        else
            break;
    }
    float idx_f = theta * Value_512_2PI;
    int idx = (int)idx_f;
    
    // 边界保护
    if (idx >= 512) idx = 511;
    if (idx < 0) idx = 0;
    
    return sin_tab[idx];
}

// 快速求解sine和cosine
void fast_sin_cos(float x, float *sin_x, float *cos_x) {
  *sin_x = fast_sin(x);
  *cos_x = fast_cos(x);
}

// int32_t 版本绝对值函数（位运算实现）
Q31_t Value_ads_q31(Q31_t x){
    return (x < 0) ? -x : x;
}

// int32_t整数开平方（查表法，求整数平方根）
Q31_t Value_sqrt_q31(Q31_t input){
    int64_t x = (int64_t)input << 31;
    // 负数直接返回 0
    if (x <= 0) return 0;
    
    // 初始估计：使用最高位位置估算
    int64_t guess = 1;
    
    // 快速找到最高位位置（类似log2）
    // 对于32位以上，使用位移快速估算初始值
    if (x > (1LL << 60)) {
        guess = 1LL << 30;
    } else if (x > (1LL << 50)) {
        guess = 1LL << 25;
    } else if (x > (1LL << 40)) {
        guess = 1LL << 20;
    } else if (x > (1LL << 30)) {
        guess = 1LL << 15;
    } else if (x > (1LL << 20)) {
        guess = 1LL << 10;
    } else if (x > (1LL << 10)) {
        guess = 1LL << 5;
    }
    
    // 牛顿迭代法： guess = (guess + x/guess) / 2
    // 迭代4-6次即可达到足够精度
    for (int i = 0; i < 6; i++) {
        int64_t new_guess = (guess + x / guess) >> 1;
        // 当误差小于1时停止迭代
        if (new_guess == guess || new_guess == guess - 1) {
            break;
        }
        guess = new_guess;
    }
    
    // 返回整数部分
    return (Q31_t)guess;
}

// 数值限幅Q31版本
Q31_t Value_Limit_q31(Q31_t val, Q31_t max, Q31_t min){
    if (val > max) return max;
    if (val < min) return min;
    return val;
}

// Q31角度归一化函数
Q31_t Value_normalize_q31(Q31_t angle_q31){    
    // int64_t angle_64 = angle_q31;
    // int64_t period_64 = Value_2PI_q31;
    
    // // 取模运算和处理负数
    // int64_t result = angle_64 % period_64;
    // if (result < 0){
    //     result += period_64;
    // }
    
    // return (Q31_t)result;
    Q31_t num = Value_2PI_q31;
    while (1) {
        if (angle_q31 > num)
            angle_q31 -= num;
        else if (angle_q31 < 0)
            angle_q31 += num;
        else
            break;
    }
    return angle_q31;
}


// ===================== Q17.15 核心函数实现 =====================
/**
 * @brief  浮点数转Q17.15定点数（1位符号+16位整数+15位小数）
 * @param  f: 待转换浮点数
 * @retval 饱和后的Q17.15定点数
 */
Q15_t IQmath_float_to_Q15(float f){
    if (f > Q15_MAX_FLOAT) return Q15_MAX;
    if (f < Q15_MIN_FLOAT) return Q15_MIN;
    
    float temp = f * Q15_MULTIPLIER;
    temp = (temp >= 0) ? (temp + 0.5f) : (temp - 0.5f);
    
    return (Q15_t)temp;
}

/**
 * @brief  Q17.15定点数转浮点数
 * @param  q: 待转换Q17.15定点数
 * @retval 转换后的浮点数
 */
float IQmath_Q15_to_float(Q15_t q){
    return (float)q * Q15_SCALE;
}

/**
 * @brief  Q17.15定点数加法（带饱和处理）
 * @param  a: 加数1（Q17.15格式）
 * @param  b: 加数2（Q17.15格式）
 * @retval 加法结果（饱和后，Q17.15格式）
 */
Q15_t IQmath_Q15_add(Q15_t a, Q15_t b){
    int64_t sum = (int64_t)a + (int64_t)b;
    
    // 饱和处理
    if (sum > Q15_MAX) return Q15_MAX;
    if (sum < Q15_MIN) return Q15_MIN;
    
    return (Q15_t)sum;
}

/**
 * @brief  Q17.15定点数减法（带饱和处理）
 * @param  a: 被减数（Q17.15格式）
 * @param  b: 减数（Q17.15格式）
 * @retval 减法结果（饱和后，Q17.15格式）
 */
Q15_t IQmath_Q15_sub(Q15_t a, Q15_t b){
    int64_t diff = (int64_t)a - (int64_t)b;
    
    // 饱和处理
    if (diff > Q15_MAX) return Q15_MAX;
    if (diff < Q15_MIN) return Q15_MIN;
    
    return (Q15_t)diff;
}

/**
 * @brief  Q17.15定点数乘法（带饱和处理）
 * @param  a: 乘数1（Q17.15格式）
 * @param  b: 乘数2（Q17.15格式）
 * @retval 乘法结果（饱和后，Q17.15格式）
 */
Q15_t IQmath_Q15_mul(Q15_t a, Q15_t b){
    int64_t temp = (int64_t)a * (int64_t)b;
    temp = (temp + (1LL << (Q15_SHIFT - 1))) >> Q15_SHIFT;
    
    // 饱和处理
    if (temp > Q15_MAX) return Q15_MAX;
    if (temp < Q15_MIN) return Q15_MIN;
    
    return (Q15_t)temp;
}

/**
 * @brief  Q17.15定点数除法（带饱和处理）
 * @param  a: 被除数（Q17.15格式）
 * @param  b: 除数（Q17.15格式）
 * @retval 除法结果（饱和后，Q17.15格式）
 */
Q15_t IQmath_Q15_div(Q15_t a, Q15_t b){
    if (b == 0) return (a >= 0) ? Q15_MAX : Q15_MIN;
    
    int64_t temp = ((int64_t)a << Q15_SHIFT) / b;
    
    // 饱和处理
    if (temp > Q15_MAX) return Q15_MAX;
    if (temp < Q15_MIN) return Q15_MIN;
    
    return (Q15_t)temp;
}


// ===================== Q31 核心函数实现 =====================

// 定点代码限幅函数
Q31_t IQmath_Q31_Limit(Q31_t value){
    if (value > Q31_MAX){
        return Q31_MAX;
    } else if (value < Q31_MIN){
        return Q31_MIN;
    }
    return value;
}

/**
 * @brief  浮点数转Q31定点(带标幺化)
 * @param  f: 待转换浮点数
 * @param  base_value: 基准值（标幺化分母）
 * @retval Q31定点数
 */
Q31_t IQmath_Q31_from_float(float f, float base_value){
    // 1. 参数验证
    double scaled;
    if (base_value <= 0.0f || f != f){  // f != f 检查NaN
        return Q31_ZERO;
    }
    else if(base_value != 1.0f){
        // 2. 标幺化
        float normalized = f / base_value;
        // 3. 饱和处理
        if (normalized >= 1.0f){
            return Q31_MAX;
        } else if (normalized <= -1.0f){
            return Q31_MIN;
        }
        // 4. 转换为Q31
        // 使用双精度提高精度：normalized * 2^31
        scaled = (double)normalized * 2147483648.0;  // 2^31
    }
    else{
        scaled = (double)f * 2147483648.0;
    }
    // 5. 四舍五入
    if (scaled >= 0.0){
        scaled += 0.5;
    } else{
        scaled -= 0.5;
    }
    // 6. 转换为整数
    int64_t result = (int64_t)scaled;
    // 7. 范围检查（防止因四舍五入溢出）
    if (result > Q31_MAX_64){
        return Q31_MAX;
    } else if (result < Q31_MIN_64){
        return Q31_MIN;
    }
    return (Q31_t)result;
}

/**
 * @brief  Q31定点转浮点数(带反标幺化)
 * @param  q: Q31定点数
 * @param  base_value: 基准值（反标幺化乘数）
 * @retval 转换后的浮点数
 */
float IQmath_Q31_to_float(Q31_t q, float base_value){
    // 1. 参数检查
    if (base_value <= 0.0f){
        return 0.0f;
    }
    // 2. Q31转归一化浮点
    double normalized = (double)q * Q31_SCALE;
    // 3. 反标幺化
    return (float)(normalized * base_value);
}

/**
 * @brief  Q31定点数乘法（带舍入和饱和）
 * @param  a: 乘数1（Q1.31格式）
 * @param  b: 乘数2（Q1.31格式）
 * @retval 乘法结果（Q1.31格式）
 */
Q31_t IQmath_Q31_mul(Q31_t a, Q31_t b){
    int64_t result = (int64_t)a * (int64_t)b;
    result += 1LL << 30;    // 四舍五入：加0.5*2^31=1<<30
    result >>= 31;          // 右移31位
    // 饱和检查
    if (result > Q31_MAX_64){
        return Q31_MAX;
    }
    if (result < Q31_MIN_64){
        return Q31_MIN;
    }
    return (Q31_t)result;
}

/**
 * @brief  Q31定点数除法（带舍入和饱和）
 * @param  a: 被除数（Q1.31格式）
 * @param  b: 除数（Q1.31格式）
 * @retval 除法结果（Q1.31格式）
 */
Q31_t IQmath_Q31_div(Q31_t a, Q31_t b){
    if (b == 0){
        // 除零：返回最大值或最小值
        return (a >= 0) ? Q31_MAX : Q31_MIN;
    }
    int64_t numerator = (int64_t)a << 31;
    int64_t result = numerator / b;
    // 计算余数用于四舍五入
    int64_t remainder = numerator % b;
    // 四舍五入
    if (remainder != 0){
        // 取余数的绝对值
        int64_t rem_abs = (remainder < 0) ? -remainder : remainder;
        int64_t b_abs = (b < 0) ? -(int64_t)b : (int64_t)b;
        // 如果余数的两倍大于等于除数，需要进位
        if (rem_abs * 2 >= b_abs){
            result += (numerator >= 0) ? 1 : -1;
        }
    }
    // 饱和检查
    if (result > Q31_MAX_64){
        return Q31_MAX;
    }
    if (result < Q31_MIN_64){
        return Q31_MIN;
    }
    return (Q31_t)result;
}

/**
 * @brief  Q31定点数加法（带饱和检查）
 * @param  a: 加数1（Q1.31格式）
 * @param  b: 加数2（Q1.31格式）
 * @retval 加法结果（Q1.31格式）
 */
Q31_t IQmath_Q31_add(Q31_t a, Q31_t b){
    int32_t sum = a + b;
    // 检查溢出：正数+正数=负数 表示正溢出
    if ((a > 0) && (b > 0) && (sum <= 0)){
        return Q31_MAX;
    }
    // 检查溢出：负数+负数=正数 表示负溢出
    if ((a < 0) && (b < 0) && (sum >= 0)){
        return Q31_MIN;
    }
    return sum;
}

/**
 * @brief  Q31定点数减法（带饱和检查）
 * @param  a: 被减数（Q1.31格式）
 * @param  b: 减数（Q1.31格式）
 * @retval 减法结果（Q1.31格式）
 * 
 */
Q31_t IQmath_Q31_sub(Q31_t a, Q31_t b){
    int32_t diff = a - b;
    // 检查溢出：正数-负数=负数 表示正溢出
    if ((a > 0) && (b < 0) && (diff <= 0)){
        return Q31_MAX;
    }
    // 检查溢出：负数-正数=正数 表示负溢出
    if ((a < 0) && (b > 0) && (diff >= 0)){
        return Q31_MIN;
    }
    return diff;
}

/**
 * @brief  Q31在不同基准值之间转换（直接计算，避免浮点误差）
 * @param  q: 源Q31值
 * @param  src_base: 源基准值
 * @param  dst_base: 目标基准值
 * @retval 转换后的Q31值
 */
Q31_t IQmath_Q31_convert_base(Q31_t q, float src_base, float dst_base){
    if (src_base <= 0.0f || dst_base <= 0.0f){
        return 0;
    }
    
    // 1. 如果基准值相同，直接返回
    if (Value_fabsf(src_base - dst_base) < 1e-6f){
        return q;
    }
    
    // 2. 直接使用比例系数转换
    // 原理：实际值 = q * src_base / 2^31
    //      新Q31 = 实际值 * 2^31 / dst_base = q * (src_base / dst_base)
    double ratio = (float)src_base / (float)dst_base;
    double result = (double)q * ratio;
    if (result > 2147483647.0){
        return Q31_MAX;  // Q31_MAX
    }
    if (result < -2147483648.0){
        return Q31_MIN;  // Q31_MIN
    }
    
    if (result >= 0){
        result += 0.5;
    } else{
        result -= 0.5;
    }
    
    return (Q31_t)result;
}

// 查表法求得Q31的角度正余弦值
static const Q31_t sin_tab_q31[512] = {
    0,26405458,52804476,79197048,105578888,131943544,158286720,184608432,210900080,237168096,263388864,
    289566688,315723040,341814976,367842464,393827040,419768640,445624320,471415616,497142464,522804896,
    548359936,573850560,599255296,624574144,649785600,674889664,699907840,724818688,749622144,774318208,
    798885376,823323776,847654720,871856896,895908672,919853120,943625792,967291072,990784512,1014127680,
    1037341952,1060384448,1083255168,1105975552,1128524160,1150900864,1173105920,1195139072,1216978944,
    1238647040,1260121984,1281403520,1302491776,1323386752,1344088576,1364575488,1384869248,1404948224,
    1424812416,1444461952,1463875200,1483095168,1502078976,1520826496,1539359232,1557655808,1575716096,
    1593540224,1611106688,1628458368,1645530880,1662388608,1678967168,1695309440,1711394176,1727199616,
    1742768896,1758059008,1773091328,1787865984,1802340096,1816577920,1830515072,1844173056,1857573376,
    1870673024,1883515008,1896056320,1908296960,1920258432,1931940736,1943322368,1954424832,1965205248,
    1975706368,1985906944,1995806848,2005406080,2014683264,2023681152,2032356992,2040732288,2048806784,
    2056559232,2064011008,2071140608,2077969664,2084476416,2090661248,2096545280,2102107264,2107347200,
    2112264960,2116860544,2121155456,2125106816,2128757632,2132064768,2135071232,2137734016,2140096256,
    2142114944,2143811456,2145207296,2146259584,2146989696,2147397760,2147483647,2147225984,2146667648,
    2145765632,2144541568,2143016832,2141148544,2138958080,2136445568,2133610880,2130454144,2126975232,
    2123174144,2119051008,2114605696,2109838208,2104748672,2099358592,2093646208,2087611776,2081255296,
    2074598016,2067618688,2060317312,2052715136,2044812416,2036587648,2028062080,2019235968,2010087680,
    2000638720,1990889088,1980838912,1970488064,1959858048,1948905856,1937674496,1926142464,1914309888,
    1902219520,1889807104,1877136896,1864166144,1850916096,1837387008,1823578752,1809491200,1795145984,
    1780500224,1765618048,1750456832,1735016448,1719318400,1703384064,1687170560,1670699392,1653991936,
    1637026816,1619803904,1602344960,1584649600,1566718208,1548529024,1530125056,1511484928,1492608512,
    1473517440,1454190080,1434647936,1414891136,1394919424,1374754560,1354353536,1333759104,1312971520,
    1291969152,1270794880,1249405952,1227845248,1206091264,1184144000,1162024832,1139734016,1117271296,
    1094636800,1071830592,1048873984,1025745536,1002488320,979059264,955479872,931750208,907891648,
    883904256,859766528,835499968,811126080,786601792,761991616,737231168,712384768,687430976,662348352,
    637179904,611925440,586563712,561116032,535582432,509984416,484300512,458530720,432696480,406797824,
    380856224,354828736,328758272,302644864,276488512,250289216,224025488,197757472,171450800,145118352,
    118762288,92389040,66002908,39606040,13202515,-13202515,-39606040,-66002908,-92389040,-118762288,
    -145118352,-171450800,-197757472,-224025488,-250289216,-276488512,-302644864,-328758272,-354828736,
    -380856224,-406797824,-432696480,-458530720,-484300512,-509984416,-535582432,-561116032,-586563712,
    -611925440,-637179904,-662348352,-687430976,-712384768,-737231168,-761991616,-786601792,-811126080,
    -835499968,-859766528,-883904256,-907891648,-931750208,-955479872,-979059264,-1002488320,-1025745536,
    -1048873984,-1071830592,-1094636800,-1117271296,-1139734016,-1162024832,-1184144000,-1206091264,
    -1227845248,-1249405952,-1270794880,-1291969152,-1312971520,-1333759104,-1354353536,-1374754560,
    -1394919424,-1414891136,-1434647936,-1454190080,-1473517440,-1492608512,-1511484928,-1530125056,
    -1548529024,-1566718208,-1584649600,-1602344960,-1619803904,-1637026816,-1653991936,-1670699392,
    -1687170560,-1703384064,-1719318400,-1735016448,-1750456832,-1765618048,-1780500224,-1795145984,
    -1809491200,-1823578752,-1837387008,-1850916096,-1864166144,-1877136896,-1889807104,-1902219520,
    -1914309888,-1926142464,-1937674496,-1948905856,-1959858048,-1970488064,-1980838912,-1990889088,
    -2000638720,-2010087680,-2019235968,-2028062080,-2036587648,-2044812416,-2052715136,-2060317312,
    -2067618688,-2074598016,-2081255296,-2087611776,-2093646208,-2099358592,-2104748672,-2109838208,
    -2114605696,-2119051008,-2123174144,-2126975232,-2130454144,-2133610880,-2136445568,-2138958080,
    -2141148544,-2143016832,-2144541568,-2145765632,-2146667648,-2147225984,-2147483648,-2147397760,
    -2146989696,-2146259584,-2145207296,-2143811456,-2142114944,-2140096256,-2137734016,-2135071232,
    -2132064768,-2128757632,-2125106816,-2121155456,-2116860544,-2112264960,-2107347200,-2102107264,
    -2096545280,-2090661248,-2084476416,-2077969664,-2071140608,-2064011008,-2056559232,-2048806784,
    -2040732288,-2032356992,-2023681152,-2014683264,-2005406080,-1995806848,-1985906944,-1975706368,
    -1965205248,-1954424832,-1943322368,-1931940736,-1920258432,-1908296960,-1896056320,-1883515008,
    -1870673024,-1857573376,-1844173056,-1830515072,-1816577920,-1802340096,-1787865984,-1773091328,
    -1758059008,-1742768896,-1727199616,-1711394176,-1695309440,-1678967168,-1662388608,-1645530880,
    -1628458368,-1611106688,-1593540224,-1575716096,-1557655808,-1539359232,-1520826496,-1502078976,
    -1483095168,-1463875200,-1444461952,-1424812416,-1404948224,-1384869248,-1364575488,-1344088576,
    -1323386752,-1302491776,-1281403520,-1260121984,-1238647040,-1216978944,-1195139072,-1173105920,
    -1150900864,-1128524160,-1105975552,-1083255168,-1060384448,-1037341952,-1014127680,-990784512,
    -967291072,-943625792,-919853120,-895908672,-871856896,-847654720,-823323776,-798885376,-774318208,
    -749622144,-724818688,-699907840,-674889664,-649785600,-624574144,-599255296,-573850560,-548359936,
    -522804896,-497142464,-471415616,-445624320,-419768640,-393827040,-367842464,-341814976,-315723040,
    -289566688,-263388864,-237168096,-210900080,-184608432,-158286720,-131943544,-105578888,-79197048,
    -52804476,-26405458,0
};

// 快速正弦算法
Q31_t fast_sin_q31(float theta){
    // Value_normalize(theta);
    while (1) {
        if (theta > 6.2831854f)
            theta = theta - 6.2831854f;
        else if (theta < 0)
            theta = theta + 6.2831854f;
        else
            break;
    }
    float idx_f = theta * Value_512_2PI;
    int idx = (int)idx_f;
    
    // 边界保护
    if (idx >= 512) idx = 511;
    if (idx < 0) idx = 0;
    
    return sin_tab_q31[idx];
}

// 快速求解sine和cosine
void fast_sin_cos_q31(float x, Q31_t *sin_x, Q31_t *cos_x){
  *sin_x = fast_sin_q31(x);
  *cos_x = fast_cos_q31(x);
}


// ============================ 定点初始化 协议层 ============================

// 读寄存器位的实际数值
uint8_t IQmath_ReadBit(uint8_t reg, uint8_t n){
    return (reg & (1 << n)) ? 1 : 0;
}

// 写寄存器为1或者0(单独写)
void IQmath_SetBit(uint8_t *reg, uint8_t n, uint8_t Bit){
    if (Bit){
        *reg |= (1 << n);
    }
    else{
        *reg &= ~(1 << n);
    }
}
